DEPENDS = "eet-native efreet evas ecore edje eet edbus ethumb eio emotion"
