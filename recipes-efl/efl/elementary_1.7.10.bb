require ${BPN}.inc

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "5b57b0f3cff32ff041bb80c463cae94a"
SRC_URI[sha256sum] = "4a9afe9d4eb0feaa803198632a5f474bdf05ebb12d12fbc7c9898add9666a2e4"
