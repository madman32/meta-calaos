require ${BPN}.inc

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "2a0b98f3558b90bfd40a84f2d937cd0a"
SRC_URI[sha256sum] = "fd10d2919b61da55b77e50061de4a0cd6119574af0c0e9e516f74a3ba9e3e86e"
