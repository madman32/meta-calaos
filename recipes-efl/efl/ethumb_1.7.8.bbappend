DEPENDS = "libexif eet-native evas ecore edje eet edbus"