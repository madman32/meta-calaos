#Fix parallel build failure

PARALLEL_MAKE = ""
