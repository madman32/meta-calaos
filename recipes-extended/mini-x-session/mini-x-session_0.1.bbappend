FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

LIC_FILES_CHKSUM = "file://mini-x-session;endline=5;md5=8f7eb7638c8aeae62eea2b749469aaea"

BBFILE_PRIORITY_${PN} = "20"

SRC_URI = "file://mini-x-session"

