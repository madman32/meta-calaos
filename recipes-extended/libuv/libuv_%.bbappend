#Add missing .pc installation

inherit pkgconfig
