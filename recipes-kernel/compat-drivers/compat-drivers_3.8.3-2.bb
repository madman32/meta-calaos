include compat-drivers.inc

SRC_URI[md5sum] = "27857413b6f17af5ea92dbb2e74ff364"
SRC_URI[sha256sum] = "2b144d3913bbc8a1dc0f252f51be97c15675d9ced28d315ed7732c2498e13c15"

