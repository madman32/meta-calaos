FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://calaos_kernel.cfg"
