include backports.inc

SRC_URI[md5sum] = "3977ee20b5f2e25daa4936687b4ab558"
SRC_URI[sha256sum] = "c5bcc86ddd2ebf5b3c9b7f5960f0199ea4ec7d463d144b9e01a9d9124dce5538"

