PACKAGECONFIG="lang-all lipi-toolkit hunspell"

