DEPENDS += "\
	libvpx \
"

PACKAGECONFIG = "libwebp libevent libpng ffmpeg webrtc opus libvpx proprietary-codecs pepper-plugins printing-and-pdf"
