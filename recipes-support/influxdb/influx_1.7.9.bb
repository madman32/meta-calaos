include influxdb.inc

inherit go

GO_IMPORT = "github.com/influxdata/influxdb/cmd/influx"

