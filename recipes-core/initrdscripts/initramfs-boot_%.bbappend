FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

FILES_${PN} += "/calaos-upgrade.sh"
